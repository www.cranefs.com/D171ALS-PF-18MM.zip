# Autodesk Inventor part: D171ALS-PF-18MM
## iProperties
Created: 2011-11
Part Number: D171ALS-PF-18MM
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
